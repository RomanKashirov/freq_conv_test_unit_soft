# Keil uVision project freq_conv_test_unit.uvprojx, settings and files
target freq_conv_test_unit (6180000::V6.18::ARMCLANG)
  device: STM32F401CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: freq_conv_test_unit
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=1 wLevel=4
  c include: .\Code\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Code
    ./Code/src/: main.c sysinit.c ledindicator.c buttons.c pwm.c
software components: RTOS:Config 10.4.6, RTOS:Core 10.4.6, RTOS:Event Groups 10.4.6, RTOS:Heap 10.4.6, RTOS:Timers 10.4.6, CMSIS:CORE 5.6.0, CMSIS:RTOS2:FreeRTOS 10.4.6, Device:Startup 2.6.3
